<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HPU_V2_Basic\EWARM\HPU_V2_Basic.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LPU_V2_Basic\EWARM\LPU_V2_Basic.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MPU_V2_Basic\EWARM\MPU_V2_Basic.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TIM_PWMOutput\EWARM\TIM_PWMOutput.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>TIM_BreakAndDeadtime</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
            <member>
                <project>TIM_DMA</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
            <member>
                <project>TIM_InputCapture</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
            <member>
                <project>TIM_OnePulse</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
            <member>
                <project>TIM_OutputCompare</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
            <member>
                <project>TIM_PWMOutput</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
            <member>
                <project>TIM_PWMOutput_Init</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
            <member>
                <project>TIM_TimeBase</project>
                <configuration>STM32F411-Nucleo</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
