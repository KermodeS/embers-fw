# IAR project MPU_V2_Basic.ewp, settings and files
configuration STM32F411-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RB ST STM32F401RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_FULL_LL_DRIVER; HSE_VALUE=8000000U
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\LLU_V2_Common; ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\inc; ..\..\..\..\..\..\Drivers\BSP\STM32F401-Discovery
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MPU_V2_Basic.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group Drivers/STM32F4xx_LL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_rcc.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group WorkingCode/EWARM
    ./: startup_stm32f411xe.s
  group WorkingCode/LLU_V2_Common
    ../../LLU_V2_Common/: LLU_V2_BIOS.c LLU_V2_ESP32.c LLU_V2_IRDA.c LLU_V2_KBD.c LLU_V2_LightControl.c
  group WorkingCode/User
    ../Src/: main.c stm32f4xx_it.c
